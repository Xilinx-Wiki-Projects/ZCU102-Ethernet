SRC_URI += "file://user_2019-09-05-13-17-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

