SRC_URI += "file://user_2019-09-05-15-05-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

