SRC_URI += "file://user_2019-09-05-11-39-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

